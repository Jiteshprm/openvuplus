SRC_DATE = "20150618_p0"

SRC_URI[md5sum] = "2af40a4381153d5684a1c64b8c2149a3"
SRC_URI[sha256sum] = "e27bdc69e93a05150f8a52bc8b98a56e3e160a533bf823d65a689f63d9130db8"
