SRCDATE = "20150403"

MODULES_NAME = "procmk\ndvb-bcm7362\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "acabb0b1a8ec12c4c27967670292f49b"
SRC_URI[sha256sum] = "4e4bf5196c32345f3733ae2731b75cd9264036762caf84b4bfe602423342ad45"
