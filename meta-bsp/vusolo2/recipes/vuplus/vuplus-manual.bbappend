SRC_DATE = "20150618_p0"

SRC_URI[md5sum] = "227cf6c973c6af907d2cdf939f3a939a"
SRC_URI[sha256sum] = "41a9129799f2870cfce1d11af1d902e55bdfc1ca2f548102359b81bb23767609"

