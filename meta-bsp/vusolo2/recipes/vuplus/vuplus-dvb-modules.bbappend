SRCDATE = "20150623"

MODULES_NAME = "procmk\ndvb-bcm7356\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "968e321582f7fc7a934c9ddfaf4de874"
SRC_URI[sha256sum] = "c9ab83b499ac3921d194db866a39d96a5abafad67c23436567ea50eb280a00ce"
