SRCDATE = "20150623"

MODULES_NAME = "procmk\ndvb-bcm7424\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "6f90a34674dd250ad57933010feaea43"
SRC_URI[sha256sum] = "bf00cc6c90303e4e31c8ae8c30a9f2cfc10a4ad5e579d762b07cd373ba8a5252"
