SRC_DATE = "20150618_p0"

SRC_URI[md5sum] = "65cbba8721b318c9209851246783fea5"
SRC_URI[sha256sum] = "25bf9d1e0c2e526f578cc4ac56e787458139590098e657575cec2493051fa4a3"

