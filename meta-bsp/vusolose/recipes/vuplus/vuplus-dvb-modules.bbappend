SRCDATE = "20150403"

MODULES_NAME = "procmk\ndvb-bcm7241\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "7325f7c9f4059f9e0720f5ce0308e6dd"
SRC_URI[sha256sum] = "9da555677bb4590240784b2eb3bfa0cd0c4b097f248b0fae1ea29ac09ba67376"
