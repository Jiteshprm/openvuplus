SRC_DATE = "20150618_p0"

SRC_URI[md5sum] = "dd715cde7d30c49499be3735fbe0950c"
SRC_URI[sha256sum] = "4c6b97d7ea15d5256d250f062ce75681f018f882af84f5be2b541bec26fa212e"
