SRCDATE = "20150406"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "210e8354a3794d83a07248ccffa109a9"
SRC_URI[sha256sum] = "79df52f2930d1f2de423f132b1beb1c718d29fbcc78b47f06478036b8bf10ba2"
