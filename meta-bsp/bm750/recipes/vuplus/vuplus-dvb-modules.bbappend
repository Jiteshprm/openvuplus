SRCDATE = "20150406"

MODULES_NAME = "procmk\ndvb-bcm7335\nbrcmfb"

SRC_URI[md5sum] = "9db378ee8efb152b7c8c32ffbfadafe6"
SRC_URI[sha256sum] = "a9e8b12e4607da07fdbe7c39623279c8d35cbb51c6c492216a9846ec5b38c0d4"
